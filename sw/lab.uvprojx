# Keil uVision project lab.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./inc/: startup.s PLL.c UART.c Unified_Port_Init.c Blynk.c Blynk.h Timer1A.c Timer1A.h Timer2A.c Timer2A.h esp8266_blynk.c esp8266_blynk.h ST7735.c ST7735.h Timer5A.c Timer5A.h
  group lib
    ./lib/TLV5616/: TLV5616.c
    ./lib/lights/: lights.c lights.h
    ./lib/motor/: motor.c motor.h
    ./lib/DAC/: DAC.c DAC.h
    ./lib/input/: input.c input.h
    ./lib/sound/: sound.c sound.h
  group src
    ./: lab.c
  group doc
    ./: README.md
  group test
    ./test/: flash.c lights_test.c motor_tests.c input_test.c
    ./: sound_test.c
